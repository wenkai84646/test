# Keil uVision project STM32L0_OLED.uvprojx, settings and files
target STM32L0_OLED (6240000::V6.24::ARMCLANG)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(16000000) ELITTLE
  output: STM32L0_OLED +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L051xx
  c include: .\;H:\Keil_v5\Arm\Packs\Keil\STM32L0xx_DFP\2.3.0\Drivers\CMSIS\Device\ST\STM32L0xx\Include;H:\Keil_v5\Arm\Packs\ARM\CMSIS\6.3.0\CMSIS\Core\Include
  asm include: H:\Keil_v5\Arm\Packs\ARM\CMSIS\6.3.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source
    ./: main.c oled.c system_stm32l0xx.c startup_stm32l051xx.s
  group Headers
    ./: oled.h font16.h
